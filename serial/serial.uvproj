# Keil uVision project serial.uvproj, settings and files
target serial (ARM-ADS)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: serial
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Serial
    ./: Serial.c Retarget.c main.c
    ../nrf24l01/nrf24l01_tx_lpc11xx/nrf24l01_send_lpc11xx/src/: cpu_lpc1000.c nrf24l01.c
    ../nrf24l01/nrf24l01_tx_lpc11xx/nrf24l01_send_lpc11xx/driver/: ssp.c
  group Headers
    ../nrf24l01/nrf24l01_tx_lpc11xx/nrf24l01_send_lpc11xx/driver/: ssp.h
    ../nrf24l01/nrf24l01_tx_lpc11xx/nrf24l01_send_lpc11xx/config/: driver_config.h
