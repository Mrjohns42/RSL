# Keil uVision project rs485.uvproj, settings and files
target RS485_Release (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RS485 +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../Common/src/: core_cm0.c system_LPC11xx.c startup_LPC11xx.s
  group App
    ./: rs485.c rs485test.c
  group Read-me
    ./: Read-me.txt
target RS485_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RS485 +hex
  c flags: Optim=1
  c define: __DEBUG_RAM
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
