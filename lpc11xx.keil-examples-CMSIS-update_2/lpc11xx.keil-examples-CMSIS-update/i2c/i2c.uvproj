# Keil uVision project i2c.uvproj, settings and files
target I2C_Debug (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: i2ctest
  c flags: Optim=1
  c define: __DEBUG_RAM
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x1c00
  memory RVCT9: RAM 0x10001c00 size 0x400
  group Source
    ./: i2c.c
    ../../../gyrocam-master/gyrocam-master/src/: gyro_main.c
    ../../../gyrocam-master/gyrocam-master/src/kalman/: kalman.c kalman.h
    ../../../gyrocam-master/gyrocam-master/src/drv/: mpu6050.c mpu6050.h
    ../../../gyrocam-master/gyrocam-master/config/: driver_config.h system_LPC11xx.h target_config.h
  group Startup
    ../Common/src/: core_cm0.c system_LPC11xx.c startup_LPC11xx.s
  group Read-me
    ./: Read-me.txt
target I2C_Release (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: i2ctest
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
