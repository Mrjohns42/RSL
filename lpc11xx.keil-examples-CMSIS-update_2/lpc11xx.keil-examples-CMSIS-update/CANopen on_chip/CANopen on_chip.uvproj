# Keil uVision project CANopen on_chip.uvproj, settings and files
target LPC11C00 (ARM-ADS)
  device: LPC11C24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: CANopen on_chip
  c flags: Optim=1
  c include: ..\Common\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ../Common/src/: system_LPC11xx.c core_cm0.c startup_LPC11xx.s
  group Source
    ./: main.c
  group Read me
    ./: abstract.txt
