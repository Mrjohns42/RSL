# Keil uVision project easyWeb.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: easyWeb +hex
  c flags: Optim=1
  c include: ..\common\inc
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ../common/src/: startup_LPC17xx.s
  group System Code
    ../common/src/: system_LPC17xx.c
  group Source Code
    ./: easyweb.c EMAC.c tcpip.c
  group Documentation
    ./: Abstract.txt
