# Keil uVision project USBMem.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBMem +hex
  c flags: Optim=1
  c define: __IRAM
  c include: .;..\Common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x2007c000 size 0x4000
  memory RVCT10: RAM 0x20080000 size 0x4000
  group Source
    ./: usbcore.c usbdesc.c usbhw.c usbuser.c mscuser.c memory.c
  group Startup
    ../common/src/: startup_LPC17xx.s
  group Disk Image
    ./: DiskImg.c
  group System
    ../common/src/: system_LPC17xx.c
  group Documentation
    ./: Abstract.txt
target FLASH (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: USBMem +hex
  c flags: Optim=1
  c include: .;..\Common\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
