# Keil uVision project nRF24L01.uvproj, settings and files
target nRF24L01 (ARM-ADS)
  device: LPC1114/202 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: nRF24L01
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ../../blinky/: system_LPC11xx.c
    ./: startup_LPC11xx.s
  group Main
    ./: main.c
  group Libraries
    ./: cpu_lpc1000.c nrf24l01.c Retarget.c
  group Driver
    ./: adc.c can.c clkconfig.c crp.c debug_printf.c gpio.c i2cslave.c lpc_swu.c rs485.c small_gpio.c ssp.c timer16.c timer32.c uart.c wdt.c mpu6050.c kalman.c mpu6050.h kalman.h type.h timer32.h
    ../../serial/: Serial.c
